# Repository Tail-BackShape/RTR24Lien-AvioSys

## KiCad design Board/RJ45hub/RJ45hub.kicad_pcb

Parts:
J1, J2, J3, J4, J5, J6: RJ45; 7810-8P8C

Connections:
CANH: J1.1, J2.1, J3.1, J4.1, J5.1, J6.1
CANL: J1.8, J2.8, J3.8, J4.8, J5.8, J6.8
GND: J1.6, J2.6, J3.6, J4.6, J5.6, J6.6
Power: J1.3, J2.3, J3.3, J4.3, J5.3, J6.3

Board: 2 copper layers, 78.7 x 32.0 mm, 6 parts (0 on the bottom side), 4 nets.

File Board/RJ45hub/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"_4, _3, _2, ",,4,,
"J1, J2, J3, J4, J5, J6",7810-8P8C,6,RJ45,

## KiCad design Board/Power/Power.kicad_pcb

Parts:
C1: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 1kV; Tolerance 100%
C2: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 1kV; Tolerance 100%
D1: D; D_SOD-323F
D2: LED; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: Conn_01x02; AMASS_XT60-F_1x02_P7.20mm_Vertical
J2: Conn_01x02; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J3: Conn_01x06; JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal
R1: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: KA78M05_TO252; TO-252-2

Connections:
5V: C2.1, J2.2, J3.1, J3.2, R1.1, U1.3 (VO)
GND: C1.2, C2.2, D2.1 (K), J1.1, J2.1, J3.5, J3.6, U1.2 (GND)
LiPo in: C1.1, D1.1 (K), U1.1 (VI)
unnamed: D1.2 (A), J1.2
unnamed: D2.2 (A), R1.2

Board: 2 copper layers, 45.7 x 33.0 mm, 9 parts (0 on the bottom side), 5 nets.

File Board/Power/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,0603,1,1uF,
C2,0603,1,0.1uF,
D1,D_SOD-323F,1,D,
D2,0603,1,LED,
J1,AMASS_XT60-F_1x02_P7.20mm_Vertical,1,Conn_01x02,
J2,JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,1,Conn_01x02,
J3,JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal,1,Conn_01x06,
R1,0603,1,100,
U1,TO-252-2,1,KA78M05_TO252,

## KiCad design Board/Main-IMU/Main-IMU.kicad_pcb

Notes on the sheet:
**コネクタルール 1がVcc 一番大きい数がGND UART/TX,RX I2C/SDA,SCL
2024/06/02 **修正** RTC:DS1307(U6)のSQWピンにPullUp抵抗を追加 書き込み回路のトランジスタ(Q1,Q2)のフットプリントを置き換え CANトランシーバーのフットプリント修正 CANBUSに電源ラインを追加

Parts:
C1, C2: 0.1μ; C_0603_1608Metric; Voltage 1kV; Tolerance 100%
C3: 10μF; C_0603_1608Metric; Voltage 1kV; Tolerance 100%
C4: 22μF; C_0603_1608Metric; Voltage 1kV; Tolerance 100%
D1: CUHS20F30; D_SOD-323F
D2: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: 5077CR-16SMC2-BK-TR; NELTRON_5077CR-16SMC2-BK-TR; PARTREV B
J2: B2B-XH-A_LF__SN_; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal; MPN B2B-XH-A(LF)(SN); Digi-Key_PN 455-2247-ND
Q1, Q2: 2SC2712-GR; SC-59_Handsoldering
R1, R2: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R5: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: CH340K; ESSOP-10_CH224K; PARTREV 3B
U2: NJM2845DL1-33; TO-252-2

Connections:
3.3V: C4.1, U2.3 (VO); also elsewhere on the board
32-TX>RX: U1.9 (RXD); also elsewhere on the board
DN: J1.A7 (DN1), J1.B7 (DN2), U1.2 (UD-)
DP: J1.A6 (DP1), J1.B6 (DP2), U1.1 (UD+)
DTR: Q2.2 (E), R4.1, U1.4 (~DTR)
EN: Q1.3 (C); also elsewhere on the board
GND: C1.1, C2.2, C3.2, C4.2, D2.1 (K), J1.A1_B12 (GND), J1.B1_A12 (GND), J1.S1 (SHIELD), J1.S2 (SHIELD), J1.S3 (SHIELD), J1.S4 (SHIELD), J2.2, R1.2, R2.2, U1.0 (EXP(GND)), U1.3 (GND), U2.2 (GND); also elsewhere on the board
IO 0: Q2.3 (C); also elsewhere on the board
K-TX>RX: U1.8 (TXD); also elsewhere on the board
unnamed: D1.2 (A), J1.A4_B9 (VBUS), J1.B4_A9 (VBUS)
unnamed: D2.2 (A), R3.2
unnamed: J1.A5 (CC1), R2.1
unnamed: J1.B5 (CC2), R1.1
unnamed: Q1.1 (B), R4.2
unnamed: Q2.1 (B), R5.2
unnamed: C2.1, U1.10 (V3)
RTS: Q1.2 (E), R5.1, U1.6 (~RTS)
ext.5V: C1.2, C3.1, D1.1 (K), J2.1, R3.1, U1.7 (VCC), U2.1 (VI); also elsewhere on the board

Parts:
C5, C6, C7: 0.1μ; C_0603_1608Metric; Voltage 1kV; Tolerance 100%
J3: DM3AT-SF-PEJM5; microSD_HC_Hirose_DM3AT-SF-PEJM5
J4: RJ45; 7810-8P8C
R6: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1, SW2: SW_Push; TVAF06-A020B-R
U3: ESP32-WROOM-32E
U4: MCP2561-E-P; DIP-8_W7.62mm_LongPads

Connections:
3.3V: J3.4 (VDD), R6.1, U3.2 (VDD); also elsewhere on the board
32-TX>RX: U3.35 (TXD0/IO1); also elsewhere on the board
CANRX: U3.9 (IO33), U4.4 (RXD)
CANTX: U3.8 (IO32), U4.1 (TXD)
CLK: J3.5 (CLK), U3.30 (IO18)
CMD: J3.3 (CMD), U3.37 (IO23)
DAT0: J3.7 (DAT0), U3.31 (IO19)
DAT3: J3.2 (DAT3/CD), U3.26 (IO4)
EN: C5.2, R6.2, SW1.2, U3.3 (EN); also elsewhere on the board
GND: C5.1, C6.1, C7.2, J3.6 (VSS), J4.6, SW1.1, SW2.1, U3.1 (GND), U3.15 (GND), U3.38 (GND), U3.39 (GND), U4.2 (VSS), U4.8 (STBY); also elsewhere on the board
IO 0: C6.2, SW2.2, U3.25 (IO0); also elsewhere on the board
K-TX>RX: U3.34 (RXD0/IO3); also elsewhere on the board
unnamed: J4.1, R7.1, U4.7 (CANH)
unnamed: J4.8, R7.2, U4.6 (CANL)
SCL: U3.36 (IO22); also elsewhere on the board
SDA: U3.33 (IO21); also elsewhere on the board
UART2-ESPtoGPS: U3.28 (IO17); also elsewhere on the board
UART2-GPStoESP: U3.27 (IO16); also elsewhere on the board
ext.5V: C7.1, J4.3, U4.3 (VDD); also elsewhere on the board

Notes on the sheet:
ESP32
CAN BUS
SD card
CAN Line Pair CTX: IO 5/ IO 12/ IO 25 CRX: IO 4/ IO 14/ IO 35 (or Any Pin?)

Parts:
C8: 100μF; C_0603_1608Metric; Voltage 1kV; Tolerance 100%
J5: B4B-XH-A_LF__SN_; JST_XH_S4B-XH-A-1_1x04_P2.50mm_Horizontal; MPN B4B-XH-A(LF)(SN); Digi-Key_PN 455-2249-ND
R8, R9: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10: 4.7k or 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U5: akizuki-BMX055; DIP-6_W7.62mm
U6: DS1307ZN+; SOIC-8_3.9x4.9mm_P1.27mm
U7: ADT7410; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 32.768kHz; Crystal_SMD_5032-2Pin_5.0x3.2mm
button_BAT1: 3.3v; BAT_CH291-1220LF

Connections:
3.3V: U5.4 (3V3), U5.6 (VCC); also elsewhere on the board
GND: C8.2, J5.4, U5.1 (GND), U6.4 (GND), U7.3 (A0), U7.4 (A1), U7.7 (GND), button_BAT1.2 (-); also elsewhere on the board
unnamed: R10.1, U6.7 (SQW/OUT)
unnamed: U6.3 (VBAT), button_BAT1.1 (+)
unnamed: U6.1 (X1), Y1.2
unnamed: U6.2 (X2), Y1.1
SCL: R9.1, U5.3 (SCL), U6.6 (SCL), U7.1 (SCL); also elsewhere on the board
SDA: R8.2, U5.2 (SDA), U6.5 (SDA), U7.2 (SDA); also elsewhere on the board
UART2-ESPtoGPS: J5.3; also elsewhere on the board
UART2-GPStoESP: J5.2; also elsewhere on the board
ext.5V: C8.1, J5.1, R8.1, R9.2, R10.2, U6.8 (VCC), U7.8 (VDD); also elsewhere on the board

Notes on the sheet:
9 Axis
Tmp
GPS
GND
RTC
I2C Addr 0x48

Board: 2 copper layers, 83.8 x 50.8 mm, 38 parts (0 on the bottom side), 34 nets.

File Board/Main-IMU/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C5, C6, C7",0603,5,0.1μ,
C3,0603,1,10μF,
C4,0603,1,22μF,
C8,0603,1,100μF,
D1,D_SOD-323F,1,CUHS20F30,
D2,0603,1,LED,
J1,NELTRON_5077CR-16SMC2-BK-TR,1,5077CR-16SMC2-BK-TR,
J2,JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,1,B2B-XH-A_LF__SN_,B2B-XH-A(LF)(SN)
J3,microSD_HC_Hirose_DM3AT-SF-PEJM5,1,DM3AT-SF-PEJM5,
J4,7810-8P8C,1,RJ45,
J5,JST_XH_S4B-XH-A-1_1x04_P2.50mm_Horizontal,1,B4B-XH-A_LF__SN_,B4B-XH-A(LF)(SN)
"Q1, Q2",SC-59_Handsoldering,2,2SC2712-GR,
"R1, R2",0603,2,5.1k,
R10,0603,1,4.7k or 5.1k,
R3,0603,1,1k,
"R4, R5, R6, R8, R9",0603,5,10k,
R7,0603,1,120,
"SW1, SW2",TVAF06-A020B-R,2,SW_Push,
U1,ESSOP-10_CH224K,1,CH340K,
U2,TO-252-2,1,NJM2845DL1-33,
U3,ESP32-WROOM-32E,1,ESP32-WROOM-32E,
U4,DIP-8_W7.62mm_LongPads,1,MCP2561-E-P,
U5,DIP-6_W7.62mm,1,akizuki-BMX055,
U6,SOIC-8_3.9x4.9mm_P1.27mm,1,DS1307ZN+,
U7,SOIC-8_3.9x4.9mm_P1.27mm,1,ADT7410,
Y1,Crystal_SMD_5032-2Pin_5.0x3.2mm,1,32.768kHz,
button_BAT1,BAT_CH291-1220LF,1,3.3v,

## KiCad design Board/AirDataCenter/AirDataCenter.kicad_pcb

Parts:
C1, C2, C3: 0.1μ; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 1kV; Tolerance 100%
J1: DM3AT-SF-PEJM5; microSD_HC_Hirose_DM3AT-SF-PEJM5
J2: RJ45; 7810-8P8C
J5, J6: B4B-XH-A_LF__SN_; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal; MPN B4B-XH-A(LF)(SN); Digi-Key_PN 455-2249-ND
R1: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1, SW2: SW_Push; TVAF06-A020B-R
U1: ESP32-WROOM-32E
U2: MCP2561-E-P; DIP-8_W10.16mm_LongPads

Connections:
3.3V: J1.4 (VDD), R1.1, U1.2 (VDD); also elsewhere on the board
32-TX>RX: U1.35 (TXD0/IO1); also elsewhere on the board
CANRX: U1.9 (IO33), U2.4 (RXD)
CANTX: U1.8 (IO32), U2.1 (TXD)
CLK: J1.5 (CLK), U1.30 (IO18)
CMD: J1.3 (CMD), U1.37 (IO23)
DAT0: J1.7 (DAT0), U1.31 (IO19)
DAT3: J1.2 (DAT3/CD), U1.26 (IO4)
EN: C1.2, R1.2, SW1.2, U1.3 (EN); also elsewhere on the board
GND: C1.1, C2.1, C3.2, J1.6 (VSS), J2.6, J5.4, J6.4, SW1.1, SW2.1, U1.1 (GND), U1.15 (GND), U1.38 (GND), U1.39 (GND), U2.2 (VSS), U2.8 (STBY); also elsewhere on the board
IO 0: C2.2, SW2.2, U1.25 (IO0); also elsewhere on the board
K-TX>RX: U1.34 (RXD0/IO3); also elsewhere on the board
unnamed: J2.1, R2.1, U2.7 (CANH)
unnamed: J2.8, R2.2, U2.6 (CANL)
SCL: U1.36 (IO22); also elsewhere on the board
SDA: U1.33 (IO21); also elsewhere on the board
UART1-RX: J5.2, U1.16 (IO13)
UART1-TX: J5.3, U1.13 (IO14)
UART2-RX: J6.2, U1.27 (IO16)
UART2-TX: J6.3, U1.28 (IO17)
ext.5V: C3.1, J2.3, J5.1, J6.1, U2.3 (VDD); also elsewhere on the board

Notes on the sheet:
ESP32
SD card
CAN Line Pair CTX: IO 32 CRX: IO 33
CAN BUS

Parts:
C4, C5: 0.1μ; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 1kV; Tolerance 100%
C6: 10μF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 1kV; Tolerance 100%
C7: 22μF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 1kV; Tolerance 100%
D1: CUHS20F30; D_SOD-323F
D2: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J3: 5077CR-16SMC2-BK-TR; NELTRON_5077CR-16SMC2-BK-TR; PARTREV B
J4: B2B-XH-A_LF__SN_; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal; MPN B2B-XH-A(LF)(SN); Digi-Key_PN 455-2247-ND
Q1, Q2: 2SC2712-GR; SC-59_Handsoldering
R3, R4: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6, R7: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U3: CH340K; ESSOP-10_CH224K; PARTREV 3B
U4: NJM2845DL1-33; TO-252-2

Connections:
3.3V: C7.1, U4.3 (VO); also elsewhere on the board
32-TX>RX: U3.9 (RXD); also elsewhere on the board
DN: J3.A7 (DN1), J3.B7 (DN2), U3.2 (UD-)
DP: J3.A6 (DP1), J3.B6 (DP2), U3.1 (UD+)
DTR: Q2.2 (E), R6.1, U3.4 (~DTR)
EN: Q1.3 (C); also elsewhere on the board
GND: C4.1, C5.2, C6.2, C7.2, D2.1 (K), J3.A1_B12 (GND), J3.B1_A12 (GND), J3.S1 (SHIELD), J3.S2 (SHIELD), J3.S3 (SHIELD), J3.S4 (SHIELD), J4.2, R3.2, R4.2, U3.0 (EXP(GND)), U3.3 (GND), U4.2 (GND); also elsewhere on the board
IO 0: Q2.3 (C); also elsewhere on the board
K-TX>RX: U3.8 (TXD); also elsewhere on the board
unnamed: D1.2 (A), J3.A4_B9 (VBUS), J3.B4_A9 (VBUS)
unnamed: D2.2 (A), R5.2
unnamed: J3.A5 (CC1), R4.1
unnamed: J3.B5 (CC2), R3.1
unnamed: Q1.1 (B), R6.2
unnamed: Q2.1 (B), R7.2
unnamed: C5.1, U3.10 (V3)
RTS: Q1.2 (E), R7.1, U3.6 (~RTS)
ext.5V: C4.2, C6.1, D1.1 (K), J4.1, R5.1, U3.7 (VCC), U4.1 (VI); also elsewhere on the board

Parts:
C8, C11, C13: 0.01μF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9, C10, C12: 1μF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C14: 10μF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D3: CUHS20F30; D_SOD-323F
R8: 4.7k or 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U5, U6, U7: MPXV7002DP
U8: ADS1115
U9: DCDC-5V
U10: BMP280-breakout
U11: DS1307ZN+; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 32.768kHz; Crystal_SMD_5032-2Pin_5.0x3.2mm
button_BAT1: 3.3v; BAT_CH291-1220LF

Connections:
1-OUT: U7.4 (VOUT), U8.8 (A0)
2-OUT: U6.4 (VOUT), U8.9 (A1)
3-OUT: U5.4 (VOUT), U8.10 (A2)
3.3V: U10.1 (3V3); also elsewhere on the board
GND: C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, U5.3 (GND), U6.3 (GND), U7.3 (GND), U8.2 (GND), U8.5 (ADDR), U9.2 (GND), U10.2 (GND), U11.4 (GND), button_BAT1.2 (-); also elsewhere on the board
unnamed: D3.1 (K), U9.1 (Vin)
unnamed: R8.1, U11.7 (SQW/OUT)
unnamed: U11.3 (VBAT), button_BAT1.1 (+)
unnamed: U11.1 (X1), Y1.2
unnamed: U11.2 (X2), Y1.1
SCL: U8.3 (SCL), U10.3 (SCL), U11.6 (SCL); also elsewhere on the board
SDA: U8.4 (SDA), U10.4 (SDA), U11.5 (SDA); also elsewhere on the board
Sensor5v: C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, U5.2 (VS), U6.2 (VS), U7.2 (VS), U8.1 (Vin), U9.3 (Vout)
ext.5V: D3.2 (A), R8.2, U11.8 (VCC); also elsewhere on the board

Notes on the sheet:
RTC
https://electronicwork.shop/items/6228175c9a70620780029691
Temp Hum Prss
Pitot tube
I2C addr ADS1115 breakout:default 0x48 DHT20:0x38

Board: 2 copper layers, 83.2 x 67.9 mm, 48 parts (0 on the bottom side), 41 nets.

File Board/AirDataCenter/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C3, C4, C5",0603,5,0.1μ,
"C10, C12, C9",0603,3,1μF,
"C11, C13, C8",0603,3,0.01μF,
"C14, C6",0603,2,10μF,
C7,0603,1,22μF,
"D1, D3",D_SOD-323F,2,CUHS20F30,
D2,0603,1,LED,
J1,microSD_HC_Hirose_DM3AT-SF-PEJM5,1,DM3AT-SF-PEJM5,
J2,7810-8P8C,1,RJ45,
J3,NELTRON_5077CR-16SMC2-BK-TR,1,5077CR-16SMC2-BK-TR,
J4,JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,1,B2B-XH-A_LF__SN_,B2B-XH-A(LF)(SN)
"J5, J6",JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,2,B4B-XH-A_LF__SN_,B4B-XH-A(LF)(SN)
"Q1, Q2",SC-59_Handsoldering,2,2SC2712-GR,
"R1, R6, R7",0603,3,10k,
R2,0603,1,120,
"R3, R4",0603,2,5.1k,
R5,0603,1,1k,
R8,0603,1,4.7k or 5.1k,
"SW1, SW2",TVAF06-A020B-R,2,SW_Push,
U1,ESP32-WROOM-32E,1,ESP32-WROOM-32E,
U10,BMP280-breakout,1,BMP280-breakout,
U11,SOIC-8_3.9x4.9mm_P1.27mm,1,DS1307ZN+,
U2,DIP-8_W10.16mm_LongPads,1,MCP2561-E-P,
U3,ESSOP-10_CH224K,1,CH340K,
U4,TO-252-2,1,NJM2845DL1-33,
"U5, U6, U7",MPXV7002DP,3,MPXV7002DP,
U8,ADS1115,1,~,
U9,DCDC-5V,1,~,
Y1,Crystal_SMD_5032-2Pin_5.0x3.2mm,1,32.768kHz,
button_BAT1,BAT_CH291-1220LF,1,3.3v,
